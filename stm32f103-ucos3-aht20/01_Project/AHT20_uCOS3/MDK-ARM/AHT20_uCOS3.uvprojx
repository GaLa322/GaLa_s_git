# Keil uVision project AHT20_uCOS3.uvprojx, settings and files
target AHT20_uCOS3 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AHT20_uCOS3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../RTOS/uC-CPU;../RTOS/uC-CPU/Cfg;../RTOS/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM;../RTOS/uC-LIB;../RTOS/uC-LIB/Cfg;../RTOS/uC-OS3/Source;../RTOS/uC-OS3/Cfg;../RTOS/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c diag.c gpio.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c app_tasks.c aht20.c bsp_uart.c bsp_i2c_hw.c bsp_i2c_sw.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group RTOS/uC-CPU
    ../RTOS/uC-CPU/: cpu_core.c
    ../RTOS/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../RTOS/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group RTOS/uC-LIB
    ../RTOS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group RTOS/uC-OS3
    ../RTOS/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../RTOS/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../RTOS/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ../RTOS/uC-OS3/Cfg/: os_app_hooks.c
software components: CMSIS:CORE 4.3.0
